# Keil uVision project DAC_TimerTrigger.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: DAC_TimerTrigger +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __NO_EMBEDDED_ASM
  c include: ..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\ABOV\A31G22x\Include;..\..\..\..\Drivers\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../../../../Core/Device/ABOV/A31G22x/Source/: system_A31G22x.c
  group Drivers
    ../../../../Drivers/source/: A31G22x_dac.c A31G22x_pcu.c A31G22x_scu.c A31G22x_timer1n.c A31G22x_uartn.c A31G22x_usart1n.c debug_frmwrk.c
  group StartUp
    ../../../../Core/Device/ABOV/A31G22x/Source/ARM/: startup_A31G21x.s
  group UserCode
    ../: main.c
