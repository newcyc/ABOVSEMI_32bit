# Keil uVision project GPIO_LedBlinky_Test.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: A33G527 ABOV Semiconductor
  pack: ABOV.G5_Series.1.0.0
  cpu: IRAM(0x20000000,0x6000) IROM(0x00000000,0x60000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPIO_LedBlinky_Test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\ABOV\A33G52x\Source\ARM;..\..\..\..\Core\Device\ABOV\A33G52x\Include;..\..\..\..\Core\Device\ABOV\A33G52x\Source;..\..\..\..\Drivers\Include;..\..\GPIO_Test
  memory RVCT4: ROM 0x0 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Main
    ../: main.c IRQ_Handler.c
  group StartUp
    ../../../../Core/Device/ABOV/A33G52x/Source/ARM/: startup_A33G52x.s
  group Drivers
    ../../../../Drivers/Source/: slib.c console.c a33g52x_uart.c a33g52x_pmu.c a33g52x_pcu.c a33g52x_nvic.c a33g52x_gpio.c
  group CMSIS-CM3
    ../../../../Core/Device/ABOV/A33G52x/Source/: system_A33G52x.c
