# Keil uVision project GPIO_LedBlinky_Test.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: GPIO_LedBlinky_Test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\ABOV\A33G52x\Source\ARM;..\..\..\..\Core\Device\ABOV\A33G52x\Include;..\..\..\..\Core\Device\ABOV\A33G52x\Source;..\..\..\..\Drivers\Include;..\..\GPIO_Test
  memory RVCT4: ROM 0x0 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Main
    ../: main.c IRQ_Handler.c
  group StartUp
    ../../../../Core/Device/ABOV/A33G52x/Source/ARM/: startup_A33G52x.s
  group Drivers
    ../../../../Drivers/Source/: slib.c console.c a33g52x_uart.c a33g52x_pmu.c a33g52x_pcu.c a33g52x_nvic.c a33g52x_gpio.c
  group CMSIS-CM3
    ../../../../Core/Device/ABOV/A33G52x/Source/: system_A33G52x.c
