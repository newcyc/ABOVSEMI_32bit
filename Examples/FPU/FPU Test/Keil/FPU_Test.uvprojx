# Keil uVision project FPU_Test.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: FPU_Test
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4, __FPU_PRESENT = 1
  c include: ..\..\..\..\Drivers\Include;..\..\..\..\core\CMSIS\Include;..\..\..\..\core\Device\ABOV\A34M41x\Include;..\..\..\..\TestCode\Include\6_FMC_SRAM_FPU;..\..\..\..\TestCode\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ../../../../core/Device/ABOV/A34M41x/Source/ARM/: startup_A34M41x.s
  group CMSIS-CM4F
    ../../../../core/Device/ABOV/A34M41x/Source/: system_A34M41x.c
  group Drivers
    ../../../../Drivers/Source/: A34M41x_debug_frmwrk.c A34M41x_hal_cfmc.c A34M41x_hal_scu.c A34M41x_hal_uart.c A34M41x_hal_pcu.c
  group Main
    ../: main.c A34M41x_it.c A34M41x_PortInit.c A34M41x_SystemClock.c
  group CMSIS DSP_Library
    ../../../../core/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
