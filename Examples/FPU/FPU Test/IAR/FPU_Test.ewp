# IAR project FPU_Test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: A34M418 ABOV A34M418
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\..\..\core\CMSIS\Include; ..\..\..\..\Drivers\Include; ..\..\..\..\core\Device\ABOV\A34M41x\Include; ..\..\..\..\TestCode\Include; ..\..\..\..\TestCode\Include\6_FMC_SRAM_FPU; ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: COMP_interrupt.srec
  ILINK.IlinkOutputFile: ADC_Burst.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ABOV\A34M418.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS_CM4F
    ../../../../Core/Device/ABOV/A34M41x/Source/: system_A34M41x.c
  group Drivers
    ../../../../Drivers/Source/: A34M41x_debug_frmwrk.c A34M41x_hal_cfmc.c A34M41x_hal_pcu.c A34M41x_hal_scu.c A34M41x_hal_uart.c
  group Main
    ../: A34M41x_it.c A34M41x_it.h A34M41x_PortInit.c A34M41x_SystemClock.c main.c main_conf.h
    ../../../../Core/CMSIS/DSP_Lib/Source/BasicMathFunctions/: arm_add_f32.c arm_mult_f32.c
  group Startup
    ../../../../Core/Device/ABOV/A34M41x/Source/ARM/: startup_A34M41x_iar.s
