# Keil uVision project RTx_Test.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: RTx_Test +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\ABOV\A33G52x\Source\ARM;..\..\..\..\Core\Device\ABOV\A33G52x\Include;..\..\..\..\Core\Device\ABOV\A33G52x\Source;..\..\..\..\Drivers\Include;..\..\..\..\RTOS\RTX\INC;..\..\..\..\RTOS\RTX\LIB\ARM
  memory RVCT4: ROM 0x0 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Main
    ../: main.c IRQ_Handler.c
  group StartUp
    ../../../../Core/Device/ABOV/A33G52x/Source/ARM/: startup_A33G52x.s
  group Drivers
    ../../../../Drivers/Source/: slib.c console.c a33g52x_uart.c a33g52x_pmu.c a33g52x_pcu.c a33g52x_nvic.c a33g52x_gpio.c
  group CMSIS-CM3
    ../../../../Core/Device/ABOV/A33G52x/Source/: system_A33G52x.c
  group CMSIS-RTOS
    ../../../../RTOS/RTX/LIB/ARM/: RTX_CM3.lib
    ../../../../RTOS/RTX/Templates/: RTX_Conf_CM.c
