# IAR project RTx_Test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: A33G527 ABOV AC33G527
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..; ..\..\..\..\Core\CMSIS\Include; ..\..\..\..\Core\Device\ABOV\A33G52x\Include; ..\..\..\..\Core\Device\ABOV\A33G52x\Source; ..\..\..\..\Drivers\Include; ..\..\..\..\RTOS\RTX\INC; ..\..\..\..\RTOS\RTX\LIB\IAR
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RTx_Test.srec
  ILINK.IlinkOutputFile: RTx_Test.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ABOV\A33G527.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../../Core/Device/ABOV/A33G52x/Source/: system_A33G52x.c
  group CMSIS-RTOS
    ../../../../RTOS/RTX/LIB/IAR/: RTX_CM3.a
    ../../../../RTOS/RTX/Templates/: RTX_Conf_CM.c
  group Drivers
    ../../../../Drivers/Source/: a33g52x_gpio.c a33g52x_nvic.c a33g52x_pcu.c a33g52x_pmu.c a33g52x_pwm.c a33g52x_uart.c a33g52x_wdt.c console.c slib.c
  group Main
    ../: IRQ_Handler.c main.c
  group Startup
    ../../../../Core/Device/ABOV/A33G52x/Source/IAR/: cstartup_A33G52x.s
