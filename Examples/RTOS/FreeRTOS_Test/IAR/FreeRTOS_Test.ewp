# IAR project FreeRTOS_Test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: A33G527 ABOV AC33G527
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\..\Core\CMSIS\Include; ..\..\..\..\Core\Device\ABOV\A33G52x\Include; ..\..\..\..\Core\Device\ABOV\A33G52x\Source; ..\..\..\..\Drivers\Include; ..\..\..\..\RTOS\FreeRTOS\Source\include; ..\..\..\..\RTOS\FreeRTOS\Source\portable\IAR\ARM_CM3; ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: FreeRTOS_Test.srec
  ILINK.IlinkOutputFile: FreeRTOS_Test.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ABOV\A33G527.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../../Core/Device/ABOV/A33G52x/Source/: system_A33G52x.c
  group Drivers
    ../../../../Drivers/Source/: a33g52x_gpio.c a33g52x_nvic.c a33g52x_pcu.c a33g52x_pmu.c a33g52x_timer.c a33g52x_uart.c a33g52x_wdt.c console.c slib.c
  group FreeRTOS
    ../../../../RTOS/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../RTOS/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../../RTOS/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group Main
    ../: IRQ_Handler.c main.c
  group Startup
    ../../../../Core/Device/ABOV/A33G52x/Source/IAR/: cstartup_A33G52x_FreeRTOS.s
