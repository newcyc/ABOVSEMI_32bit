# Keil uVision project FMC_EraseWrite.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: FMC_WriteErase +hex
  c flags: Optim=1 wLevel=2
  c define: __NO_EMBEDDED_ASM
  c include: ..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\ABOV\A31G22x\Include;..\..\..\..\Drivers\include;..\..\FMC_WriteErase
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x20003000 size 0x2000
  group CMSIS
    ../../../../Core/Device/ABOV/A31G22x/Source/: system_A31G22x.c
  group Drivers
    ../../../../Drivers/source/: A31G22x_pcu.c A31G22x_scu.c
  group StartUp
    ../../../../Core/Device/ABOV/A31G22x/Source/ARM/: startup_A31G21x.s
  group UserCode
    ../: flash.c main.c
