<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\FMC_EraseWrite_Lock_inRAM.ewp</path>
  </project>
  <batchBuild/>
</workspace>


