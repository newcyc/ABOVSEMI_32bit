# IAR project FMC_EraseWrite_Lock_inRAM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: A31G226 ABOV A31G226
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..; ..\..\..\..\Core\Device\ABOV\A31G22x\Include; ..\..\..\..\Core\CMSIS\Include; ..\..\..\..\Drivers\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FMC_EraseWrite_Lock_inRAM.srec
  ILINK.IlinkOutputFile: FMC_EraseWrite_Lock_inRAM.out
  ILINK.IlinkIcfFile: Linker\FMC_EraseWrite_Lock_inRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../../Core/Device/ABOV/A31G22x/Source/: system_A31G22x.c
  group Drivers
    ../../../../Drivers/source/: A31G22x_pcu.c A31G22x_scu.c
  group Startup
    ../../../../Core/Device/ABOV/A31G22x/Source/IAR/: cstartup_A31G22x.s
  group UserCode
    ../: flash.c main.c
