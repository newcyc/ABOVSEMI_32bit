# IAR project WDT_Interrupt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: A34M418 ABOV A34M418
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\..\..\..\core\CMSIS\Include; ..\..\..\..\Drivers\Include; ..\..\..\..\core\Device\ABOV\A34M41x\Include; ..\..\..\..\TestCode\Include; ..\..\..\..\TestCode\Include\7_FRT_TIMER_WDT; ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: COMP_interrupt.srec
  ILINK.IlinkOutputFile: WDT_Interrupt.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ABOV\A34M418.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS_CM4F
    ../../../../core/Device/ABOV/A34M41x/Source/: system_A34M41x.c
  group Drivers
    ../../../../Drivers/Source/: A34M41x_debug_frmwrk.c A34M41x_hal_cfmc.c A34M41x_hal_pcu.c A34M41x_hal_scu.c A34M41x_hal_uart.c A34M41x_hal_wdt.c
  group Main
    //210.102.6.50/MSSGroup/PTS팀/32bit/SW TF/A34M418/part2/A34M41x_EVK_191108/Examples/WDT/WDT_Interrupt/: A34M41x_it.c A34M41x_it.h A34M41x_PortInit.c A34M41x_SystemClock.c main.c main_conf.h
  group Startup
    ../../../../core/Device/ABOV/A34M41x/Source/ARM/: startup_A34M41x_iar.s
