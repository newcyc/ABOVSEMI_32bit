# Keil uVision project arm_cortexM4lf_dotproduct_example.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: arm_cortexM4lf_dotProduct_example
  c flags: Optim=1 wLevel=2
  c define: ARM_MATH_CM4, __FPU_PRESENT = 1
  c include: ..\..\..\..\Include;..\..\..\..\..\Device\ARM\ARMCM4\Include;..\..\..\Common\Include
  group Source Group 1
    ../: arm_dotproduct_example_f32.c
  group CMSIS Device
    ../../Common/ARM/: startup_ARMCM4.s
    ../../Common/: system_ARMCM4.c
  group CMSIS DSP_Library
    ../../../../Lib/ARM/: arm_cortexM4lf_math.lib
